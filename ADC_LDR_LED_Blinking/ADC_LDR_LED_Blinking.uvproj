# Keil uVision project ADC_LDR_LED_Blinking.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_LDR_LED_Blinking +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ADC_LDR_LED_Blinking_main.c lcd.h lcd.c delay.h delay.c
