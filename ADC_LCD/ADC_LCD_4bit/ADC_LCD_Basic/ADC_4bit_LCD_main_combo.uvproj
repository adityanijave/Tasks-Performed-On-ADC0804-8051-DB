# Keil uVision project ADC_4bit_LCD_main_combo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_4bit_LCD_main_combo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ADC_4bit_LCD_main_combo.c delay.c delay.h lcd.h lcd.c
