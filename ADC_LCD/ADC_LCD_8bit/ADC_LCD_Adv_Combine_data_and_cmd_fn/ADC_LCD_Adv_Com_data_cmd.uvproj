# Keil uVision project ADC_LCD_Adv_Com_data_cmd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_LCD_Adv_Com_data_cmd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 adc.c adc.h ADC_LCD_main.c delay.c delay.h lcd.c lcd.h
