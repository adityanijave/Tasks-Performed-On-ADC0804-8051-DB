# Keil uVision project ADC_LCD_main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_LCD_main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ADC_LCD_main.c delay.c lcd.c delay.h lcd.h adc.h adc.c
