# Keil uVision project ADC_LDR_Motor_Control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_LDR_Motor_Control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ADC_LDR_Motor_Control_main.c delay.c delay.h lcd.h lcd.c
